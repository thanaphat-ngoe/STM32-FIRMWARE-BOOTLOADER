# Keil uVision project arm_bayes_example.uvprojx, settings and files
target ARMCM0 (6180000::V6.18::..\..\Program Files (x86)\ArmCompilerforEmbedded6.18)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(10000000) ELITTLE
  output: arm_bayes_example
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\RTE\Device\ARMCM0\ARMCM0_ac6.sct
  group Source Files
    ./: arm_bayes_example_f32.c
  group Documentation
    ./: Abstract.txt
target ARMCM3 (6180000::V6.18::..\..\Program Files (x86)\ArmCompilerforEmbedded6.18)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(10000000) ELITTLE
  output: arm_bayes_example
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\RTE\Device\ARMCM3\ARMCM3_ac6.sct
target ARMCM4_FP (6180000::V6.18::..\..\Program Files (x86)\ArmCompilerforEmbedded6.18)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: arm_bayes_example
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\RTE\Device\ARMCM4_FP\ARMCM4_ac6.sct
target ARMCM7_SP (6180000::V6.18::..\..\Program Files (x86)\ArmCompilerforEmbedded6.18)
  device: ARMCM7_SP ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ESEL ELITTLE
  output: arm_bayes_example
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\RTE\Device\ARMCM7_SP\ARMCM7_ac6.sct
target ARMCM55_FP_MVE (6180000::V6.18::..\..\Program Files (x86)\ArmCompilerforEmbedded6.18)
  device: ARMCM55 ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IRAM(0x30000000,0x00020000) IRAM2(0x20000000,0x00020000) IROM(0x10000000,0x00200000) IROM2(0x00000000,0x00200000) CPUTYPE("Cortex-M55") FPU3(DFPU) DSP TZ MVE(FP) CLOCK(12000000) ESEL ELITTLE
  output: arm_bayes_example
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: ARM_MATH_MVEF
  memory RVCT4: ROM 0x10000000 size 0x200000
  memory RVCT5: ROM 0x0 size 0x200000
  memory RVCT9: RAM 0x30000000 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: .\RTE\Device\ARMCM55\ARMCM55_ac6.sct
software components: CMSIS:CORE 5.4.0, CMSIS:DSP 1.8.0, Device:Startup 2.0.2, Device:Startup 2.0.2, Device:Startup 2.0.2, Device:Startup 1.0.0, Device:Startup 2.0.2
