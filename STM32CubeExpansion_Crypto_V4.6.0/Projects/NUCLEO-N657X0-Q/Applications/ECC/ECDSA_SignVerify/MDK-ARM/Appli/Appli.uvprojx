# Keil uVision project Appli.uvprojx, settings and files
target Appli - ECDSA_SignVerify (6210000::V6.21::ARMCLANG)
  device: STM32N657X0HxQ STMicroelectronics
  pack: Keil.STM32N6xx_DFP.1.0.0
  cpu: IRAM(0x00000000,0x00040000) IRAM2(0x20000000,0x00040000) XRAM(0x24000000,0x3E0000) XRAM2(0x25000000,0x01000000) XRAM3(0x28000000,0x00008000) CPUTYPE("Cortex-M55") FPU3(SFPU) DSP TZ CLOCK(12000000) ESEL ELITTLE
  output: Appli
  AfterMake: fromelf.exe --bin Objects\Appli.axf  --output=$L"\..\..\..\Binary\Appli.bin"
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: STM32N657xx,USE_HAL_DRIVER, DATATYPE
  c include: ../../Appli/Inc;../../../../../../../Drivers/CMSIS/Include;../../../../../../../Drivers/CMSIS/Device/ST/STM32N6xx/Include;../../../../../../../Drivers/STM32N6xx_HAL_Driver/Inc;../../../../../../../Drivers/BSP/STM32N6xx_Nucleo;../../../../../../../Middlewares/ST/STM32_Cryptographic/include
  library: MicroLIB
  memory RVCT4: ROM 0x70100400 size 0x1dfc00
  memory RVCT6: RAM 0x24000000 size 0x3e0000
  memory RVCT7: RAM 0x25000000 size 0x1000000
  memory RVCT8: RAM 0x28000000 size 0x8000
  memory RVCT9: RAM 0x34000000 size 0x100000
  memory RVCT10: RAM 0x20000000 size 0x40000
  scatter file: .\stm32n657xx_XIP.sct
  link misc: --diag_suppress L6848W
  group Drivers/BSP
    ../../../../../../../Drivers/BSP/STM32N6xx_Nucleo/: stm32n6xx_nucleo.c
  group Drivers/CMSIS
    ../../Appli/Src/: system_stm32n6xx_s.c
  group Example/MDK-ARM
    ./: startup_stm32n657xx.c
  group Drivers/STM32N6xx_HAL_Drivers
    ../../../../../../../Drivers/STM32N6xx_HAL_Driver/Src/: stm32n6xx_hal.c stm32n6xx_hal_cortex.c stm32n6xx_hal_gpio.c stm32n6xx_hal_pwr.c stm32n6xx_hal_pwr_ex.c stm32n6xx_hal_exti.c stm32n6xx_hal_uart.c stm32n6xx_hal_uart_ex.c stm32n6xx_hal_dma.c stm32n6xx_hal_dma_ex.c stm32n6xx_hal_rcc.c stm32n6xx_hal_rcc_ex.c stm32n6xx_hal_bsec.c stm32n6xx_hal_rng.c stm32n6xx_hal_rng_ex.c
  group Example/User
    ../../Appli/Src/: main.c stm32n6xx_hal_msp.c stm32n6xx_it.c cmox_low_level.c
  group Middlewares/STM32Cryptographic
    ../../../../../../../Middlewares/ST/STM32_Cryptographic/lib/: libSTM32Cryptographic_CM55.a
