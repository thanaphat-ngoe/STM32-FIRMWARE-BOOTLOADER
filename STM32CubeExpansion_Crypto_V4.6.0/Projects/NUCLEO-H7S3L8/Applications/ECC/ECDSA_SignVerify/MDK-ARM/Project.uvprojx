# Keil uVision project Project.uvprojx, settings and files
target NUCLEO-H7S3L8_ECDSA_SignVerify (6140001::V6.14.1::ARMCLANG)
  device: STM32H7S3L8Hx STMicroelectronics
  pack: Keil.STM32H7RSxx_DFP.1.0.1
  cpu: IRAM(0x20000000,0x20000) IROM(0x08000000,0x010000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: STM32H7RSxx,STM32H7S3xx,USE_HAL_DRIVER
  c include: ../Inc;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/CMSIS/Device/ST/STM32H7RSxx/Include;../../../../../../Drivers/STM32H7RSxx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM32H7RSxx_Nucleo;../../../../../../Middlewares/ST/STM32_Cryptographic/include;../../../../../../Drivers/BSP/STM32H7RSxx_Nucleo
  memory RVCT4: ROM 0x70000000 size 0x10000000
  memory RVCT9: RAM 0x24000000 size 0x72000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: ../../../../../../Drivers/CMSIS/Device/ST/STM32H7RSxx/Source/Templates/arm/linker/stm32h7rsxx_ROMxspi2.sct
  link misc: --diag_suppress L6312,L6314
  group Application/User
    ../Src/: stm32h7rsxx_it.c stm32h7rsxx_hal_msp.c cmox_low_level.c main.c entropy.c
  group Application/MDK-ARM
    ./: startup_stm32h7s3xx.s
  group Doc
    ../: readme.txt
  group Drivers/STM32H7RSxx_HAL_Driver
    ../../../../../../Drivers/STM32H7RSxx_HAL_Driver/Src/: stm32h7rsxx_hal.c stm32h7rsxx_hal_cortex.c stm32h7rsxx_hal_gpio.c stm32h7rsxx_hal_pwr.c stm32h7rsxx_hal_pwr_ex.c stm32h7rsxx_hal_rcc.c stm32h7rsxx_hal_rcc_ex.c stm32h7rsxx_hal_exti.c stm32h7rsxx_hal_dma.c stm32h7rsxx_hal_dma_ex.c stm32h7rsxx_hal_tim.c stm32h7rsxx_hal_tim_ex.c
  group Drivers/BSP/STM32H7RSxx_Nucleo
    ../../../../../../Drivers/BSP/STM32H7RSxx_Nucleo/: stm32h7rsxx_nucleo.c
  group Drivers/CMSIS
    ../Src/: system_stm32h7rsxx.c
  group Middlewares/STM32Cryptographic
    ../../../../../../Middlewares/ST/STM32_Cryptographic/lib/: libSTM32Cryptographic_CM7.a
software components: CMSIS:CORE 4.3.0
