# Keil uVision project Project.uvprojx, settings and files
target NUCLEO-U385RG-Q_ECDSA_SignVerify (6140001::V6.14.1::ARMCLANG)
  device: STM32U385RGTxQ STMicroelectronics
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x20030000-0x2003FFFF) IROM(0x08000000-0x80FFFFF) CLOCK(8000000) FPU3(SFPU) CPUTYPE("Cortex-M33") ELITTLE TZ DSP
  output: Project +hex
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: STM32U385xx,USE_HAL_DRIVER,USE_FULL_ASSERT
  c include: ../Inc;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/CMSIS/Device/ST/STM32U3xx/Include;../../../../../../Drivers/STM32U3xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM32U3xx_Nucleo;../../../../../../Drivers/BSP/Components/Common;../../../../../../Drivers/STM32U3xx_HAL_Driver/Inc/Legacy;../../../../../../Middlewares/ST/STM32_Cryptographic/include;../../../../../../Drivers/BSP/STM32U3xx_Nucleo
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x20030000 size 0x10000
  group Application/User
    ../Src/: stm32u3xx_it.c stm32u3xx_hal_msp.c cmox_low_level.c main.c
  group Application/MDK-ARM
    ./: startup_stm32u385xx.s
  group Doc
    ../: readme.txt
  group Drivers/STM32U3xx_HAL_Driver
    ../../../../../../Drivers/STM32U3xx_HAL_Driver/Src/: stm32u3xx_hal.c stm32u3xx_hal_cortex.c stm32u3xx_hal_gpio.c stm32u3xx_hal_pwr.c stm32u3xx_hal_pwr_ex.c stm32u3xx_hal_rcc.c stm32u3xx_hal_rcc_ex.c stm32u3xx_hal_exti.c stm32u3xx_hal_icache.c stm32u3xx_hal_rng.c stm32u3xx_hal_rng_ex.c
  group Drivers/BSP/STM32U3xx_Nucleo
    ../../../../../../Drivers/BSP/STM32U3xx_Nucleo/: stm32u3xx_nucleo.c
  group Drivers/CMSIS
    ../Src/: system_stm32u3xx.c
  group Middlewares/STM32Cryptographic
    ../../../../../../Middlewares/ST/STM32_Cryptographic/lib/: libSTM32Cryptographic_CM33.a
software components: CMSIS:CORE 5.6.0
